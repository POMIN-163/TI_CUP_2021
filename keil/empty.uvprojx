# Keil uVision project empty.uvprojx, settings and files
target empty (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=7 wLevel=1
  c include: ../source;../source/third_party/CMSIS/Include/;..\user;..\opencode\cm_backtrace;..\opencode;..\opencode\kissfft;..\source\ti\devices\msp432e4\driverlib\inc;..\uicode
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../user/: main.c tc_it.c tc_adc.c tc_lcd.c tc_led.c tc_tick.c tc_key.c tc_fft.lib tc_uart.c tc_freq.c tc_timer.c tc_global.c tc_bluetooth.c
    ../: system_msp432e401y.c
    ./: startup_msp432e401y_uvision.s
  group Library
    ../user/: uartstdio.c scheduler.c
    ../opencode/cm_backtrace/fault_handler/keil/: cmb_fault.S
    ../opencode/cm_backtrace/: cm_backtrace.c
    ../source/ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
software components: CMSIS:CORE 5.4.0
